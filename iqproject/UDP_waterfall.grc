options:
  parameters:
    generate_options: qt_gui
    id: w2
    output_language: python
    title: FlexRadio WWV obsever
  states: {}

blocks:
- name: decimation
  id: variable_qtgui_entry
  parameters:
    label: Decimation
    type: int
    value: '48'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: variable_qtgui_entry_1
  id: variable_qtgui_entry
  parameters:
    label: Min signal db
    type: int
    value: '-60'
  states: {}
- name: variable_qtgui_entry_2
  id: variable_qtgui_entry
  parameters:
    label: Max signal db
    type: int
    value: '30'
  states: {}
- name: variable_qtgui_entry_3
  id: variable_qtgui_entry
  parameters:
    label: Decimated max db
    type: int
    value: '-20'
  states: {}
- name: variable_qtgui_entry_4
  id: variable_qtgui_entry
  parameters:
    label: Decimated min db
    type: int
    value: '-60'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '8192'
    port: '8790'
    src_zeros: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '10'
    fc: '0'
    fftsize: '512'
    type: complex
    ymax: variable_qtgui_entry_3
    ymin: variable_qtgui_entry_4
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '10'
    fc: '0'
    fftsize: '4096'
    int_max: '-20'
    int_min: '-60'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    int_max: variable_qtgui_entry_2
    int_min: variable_qtgui_entry_1
    type: complex
  states: {}

connections:
- [analog_agc3_xx_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_conjugate_cc_0, '0', low_pass_filter_0, '0']
- [blocks_conjugate_cc_0, '0', qtgui_waterfall_sink_x_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [network_udp_source_0, '0', analog_agc3_xx_0, '0']

metadata:
  file_format: 1
